# Keil uVision project TIM22_CH1_PWM.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32L053C8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TIM22_CH1_PWM
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Device
    ./Device/: startup_stm32l053xx.s system_stm32l0xx.c
  group Source
    ./Source/: TIM22_CH1_PWM_main.c
  group Library
    ./Library/: System_Clock_MSI.c TIM22_CH1_PWM_Lib.c TIM22_IRQHandler.c.c
  group Abstract
    ./: 3-P_TIM22_CH1_PWM_Abstract.txt
  group Include
    ./Include/: System_Clock.h TIM22_CH1_PWM_Lib.h user_STM32L053Disco.h
software components: CMSIS:CORE 4.1.0
